# Keil uVision project stm32h7xx_template.uvprojx, settings and files
target template (6100001::V6.10.1::.\ARMCompiler6_10_1)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32h7xx_template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx,USE_HAL_DRIVER,USE_USB_OTG_FS
  c include: ..\..\HAL-Library\cmsis;..\..\HAL-Library\library\Inc;..\..\HAL-Library\library\Src;..\..\HAL-Library\config;..\..\Include;..\..\KEIL-Template;..\..\App-Demo;..\..\App-GUI;..\..\Framework\event;..\..\Framework\gui-handle;..\..\Framework\hw-handle;..\..\Hardware\audio;..\..\Hardware\ethernet;..\..\Hardware\io_expand;..\..\Hardware\key;..\..\Hardware\lcd;..\..\Hardware\led;..\..\Hardware\flash;..\..\Hardware\sdcard;..\..\Hardware\sdram;..\..\Hardware\sensor;..\..\Hardware\sys_i2c;..\..\Hardware\touch;..\..\Hardware\usart;..\..\Hardware\usb_fs;..\..\Hardware\wifi;..\..\Middleware\Codec\wav;..\..\Middleware\FatFS\cfg;..\..\Middleware\FatFS\src;..\..\System\config;..\..\System\debug;..\..\System\delay;..\..\System\font;..\..\System\malloc;..\..\System\timedate;..\..\uCOS-II\cfg;..\..\uCOS-II\src;..\..\USB-OTG\STM32_USB_Config;..\..\USB-OTG\STM32_USB_Device_Library\Core\Inc;..\..\USB-OTG\STM32_USB_Host_Library\Class\MSC\Inc;..\..\USB-OTG\STM32_USB_Host_Library\Core\Inc;..\..\Framework\text;..\..\Framework\icon;..\..\System\packet;..\..\Middleware\InfoNES\cfg;..\..\Middleware\InfoNES\src;..\..\Middleware\InfoNES\src\mapper
  asm define: FPU_HFPU
  asm include: ..\..\KEIL-Template;..\..\uCOS-II\cfg;..\..\uCOS-II\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\template.sct
  group startup
    ../: startup_stm32h743xx.s system_stm32h7xx.c
  group main
    ../: template.c
  group app-gui
    ../../App-GUI/: app_move_block.c app_music_player.c base_home.c
  group app-demo
    ../../App-Demo/: app_demo.c app_ds18b20_test.c app_hzkfont_test.c app_mymalloc_test.c app_qspiflash_test.c app_sdcard_test.c app_sdfatfs_test.c app_sdram_test.c app_uart_txrx_test.c app_usbhost_test.c app_wavdec_test.c app_wlan_test.c app_lcd_dma_test.c app_tp_test.c app_nes_test.c
  group include
    ../../Include/: public.c
  group hal-library
    ../../HAL-Library/config/: stm32h7xx_it.c
    ../../HAL-Library/library/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group system
    ../../System/config/: system_core_conf.c
    ../../System/debug/: printf.c
    ../../System/delay/: delay.c
    ../../System/font/: font.c font_update.c
    ../../System/malloc/: my_malloc.c
    ../../System/packet/: packet.c
  group hardware
    ../../Hardware/audio/: audio_api.c audio_sai.c WM8978G.c
    ../../Hardware/io_expand/: io_expand.c
    ../../Hardware/key/: io_keypad.c ir_keypad.c
    ../../Hardware/lcd/: lcd.c lcd_gram.c
    ../../Hardware/led/: led.c
    ../../Hardware/sdcard/: sdcard.c sdcard_diskio.c
    ../../Hardware/sdram/: sdram.c
    ../../Hardware/sensor/: ds18b20.c
    ../../Hardware/sys_i2c/: sys_i2c.c
    ../../Hardware/touch/: touch.c
    ../../Hardware/usart/: uart_atk.c uart_debug.c
    ../../Hardware/wifi/: wifi_esp8266.c
    ../../Hardware/flash/: nand_flash.c qspi_flash.c stm_flash.c
  group framework
    ../../Framework/event/: ui_event.c
    ../../Framework/hw-handle/: kpd_track.c screen_refresh.c tp_track.c usb_host_track.c
    ../../Framework/gui-handle/: ui_applet.c ui_screen.c gui_app_handle.c gui_startup.c app_hooks.c ui_screen_field.c ui_list.c
    ../../Framework/text/: text.c
    ../../Framework/icon/: icon.c
  group wav-codec
    ../../Middleware/Codec/wav/: wav_codec.c wav_decode.c wav_encode.c
  group fatfs
    ../../Middleware/FatFS/cfg/: diskio.c fatfs_ex.c
    ../../Middleware/FatFS/src/: ff.c ffsystem.c ffunicode.c
  group ucos-ii
    ../../uCOS-II/cfg/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../../uCOS-II/src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group usb-config
    ../../USB-OTG/STM32_USB_Config/: usbh_conf.c usb_host.c usbh_diskio.c
  group usb-host
    ../../USB-OTG/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../USB-OTG/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group infones
    ../../Middleware/InfoNES/cfg/: InfoNES_System_ARM.c
    ../../Middleware/InfoNES/src/: InfoNES.c InfoNES_Mapper.c InfoNES_pAPU.c K6502.c
